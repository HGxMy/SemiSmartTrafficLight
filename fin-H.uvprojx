# Keil uVision project fin-H.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\DriverAPP;.\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./DriverAPP/: led.h led.c key.c key.h
  group User
    ./User/: main.c stm32f10x_it.c time2.c time2.h Delay.c Delay.h usart.c usart.h exti.c exti.h
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c stm32f10x_usart.c misc.c
  group Cmsis
    ../../STM32F1xx固件库/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../STM32F1xx固件库/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group STdriver
    ../../STM32F1xx固件库/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c
